# Keil uVision project UART1.uvproj, settings and files
target UART1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: UART1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group USER
    ./: main.c
